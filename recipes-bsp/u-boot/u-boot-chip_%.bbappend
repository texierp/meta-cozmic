FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-chip-dip-handle-multiple-DIPs.patch \
	"
