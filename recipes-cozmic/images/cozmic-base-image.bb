DESCRIPTION = "cozmic image minimal, to get the hardware running"

inherit cozmic-base-image
